# IAR project SoftUart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: ..\; ..\CMSIS; ..\Level1_StdPeriphDriver\inc; ..\Level2_SoftUart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SoftUart.srec
  ILINK.IlinkOutputFile: b_cntr.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../: main.c startup_stm32f103xb.s
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group Level1_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group Level2_SoftUart
    ../Level2_SoftUart/: L2_SoftUart.c ring_buffer.c
